Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-05-11T10:39:02
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort
FlowDirection: SINK
Pset_DistributionPortPipe - PortNumber: 1; ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 15 mm; ConnectorDiameter: 15 mm; NominalWidth: 15 mm; NominalHeight: 15 mm

# IfcEnergyConversionDevice: Line-sensor Technology Square Extend Sensor Faucet, FFAS8510-A00500BC0:Line-sensor Technology Square Extend Sensor Faucet:4329
In: Level 1
Pset_ManufacturerTypeInformation - ModelReference: Line-sensor Technology Square Extend Sensor Faucet; Manufacturer: American Standard; ProductionYear: 2021
Constraints - Elevation: 0 mm
Construction - AeratorOffset: 450 mm
Dimensions - Area: 0.0918168 m2; Volume: 0.0021491 m3
Identity Data - Mark: 1
Mechanical - System Classification: Hydronic Supply
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: FFAS8510-A00500BC0: Line-sensor Technology Square Extend Sensor Faucet; Family and Type: FFAS8510-A00500BC0: Line-sensor Technology Square Extend Sensor Faucet; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: FFAS8510-A00500BC0: Line-sensor Technology Square Extend Sensor Faucet; Type Id: FFAS8510-A00500BC0: Line-sensor Technology Square Extend Sensor Faucet; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: n/a; InstallationType: n/a; ProductCategory: Pro & Commercial (70); ProductGroup: Sensor Faucet (03); ProductWeight: n/a; StyleSegment: n/a; SubCategory: Commercial Fittings (72)
Identity Data(Type) - Assembly Code: G3010; Description: Line-sensor Technology Square Extend Sensor Faucet; Keynote: N13; Manufacturer: American Standard; Model: Line-sensor Technology Square Extend Sensor Faucet; OmniClass Number: 23.45.55.14; OmniClass Title: Single Faucets; Type Comments: FFAS8510-A00500BC0; Type Name: Line-sensor Technology Square Extend Sensor Faucet; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: JY; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ffas8510-a00500bc0/document/object-user-guide; BIMObjectName: AmericanStandard_SensorFaucet_LineSensorTechnology_(FFAS8510-A00500BC0); NBSDescription: Water supply fittings for wash basins and troughs; NBSNote: n/a; NBSObjectName: American Standard - Water supply fittings for wash basins and troughs; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/371
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_87_98; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ffas8510-a00500bc0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ffas8510-a00500bc0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ffas8510-a00500bc0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ffas8510-a00500bc0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ffas8510-a00500bc0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: FFAS8510-A00500BC0; Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: FFAS8510-A00500BC0; ModelReference: Line-sensor Technology Square Extend Sensor Faucet; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Line-sensor Technology Square Extend Sensor Faucet; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
